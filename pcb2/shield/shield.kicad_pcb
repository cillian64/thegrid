# Repository cillian64/thegrid

File README.md:

# The·Grid

The·Grid is an installation at [EMF](https://emfcamp.org) 2014 and 2016. This 
repository contains the hardware, firmware, software, and miscellaneous 
documentation and scripts that go with it.

## Hardware
All the PCB designs live in the `hardware/` folder. They're done in KiCAD.

## Firmware
The firmware that runs on the pole PCBs (new in 2016), which controls the RGB 
LED and buzzer and reads data from the serial bus, lives in `firmware/polefw`.

The firmware that runs on the driver PCB, which is basically a glorified USB to 
RS422 serial widget, lives in `firmware/driverfw`.

Both use ChibiOS (16.1) so you should `git submodule update --init` to get that 
checked out. Additionally you'll want to patch a bug in ChibiOS, see the README 
in `firmware/` for more details.

## Software
The software runs code-defined patterns of light and sound on The·Grid itself. 
It's written in Python 3, using asyncio, with some WebGL for an in-browser 
simulation.

It's fairly easy to add your own patterns, please see the README in `software/` 
for more details.

## KiCad design pcb2/shield/shield.kicad_pcb

Parts:
C1, C2: 100n; 0603; Farnell 2496833
C3, C6, C8: 100n; 0603
C4: 10u; 0603
C5: C; 0603
C7, C9, C10: 1u; 0603
IC1: STM32F0xxKxTx; LQFP-32; Farnell 2469553
IC2: MCP1700; SOT-23; Farnell 1296592
IC3, IC4: AM26C31; SOIC-16; Farnell 4975637
J1: MICROUSB; MICROUSB_MOLEX_47589-0001; Farnell 1568023
P1: SWD_TC; TC2030-NL
P5: SHIFT; Pin_Header_Straight_1x04
P6: BUS1; S02B-PASK-2; Farnell 1830747
P7: BUS2; S02B-PASK-2; Farnell 1830747
P8: BUS3; S02B-PASK-2; Farnell 1830747
P9: BUS4; S02B-PASK-2; Farnell 1830747
P10: BUS5; S02B-PASK-2; Farnell 1830747
P11: BUS6; S02B-PASK-2; Farnell 1830747
P12: BUS7; S02B-PASK-2; Farnell 1830747
P13: BUS8; S02B-PASK-2; Farnell 1830747
X1, X2, X3, X4: PART; M3_MOUNT

Connections:
+3V3: C3.1, C4.1, C6.1, C7.1, C8.1, C10.1, IC1.1 (VDD), IC1.5 (VDDA), IC1.17 (VDD), IC2.2 (VOUT), P1.1 (VDD)
+5V: C1.1, C2.1, C9.1, IC2.3 (VIN), IC3.16 (VCC), IC4.16 (VCC), J1.1 (VCC)
/SHIFT_DATA: IC1.13 (PA7), P5.4
/SHIFT_RCK: IC1.11 (PA5), P5.2
/SHIFT_SRCK: IC1.12 (PA6), P5.3
/SWDCLK: IC1.24 (PA14), P1.4 (SWDCLK)
/SWDIO: IC1.23 (PA13), P1.2 (SWDIO)
/TX: IC1.8 (PA2), IC3.1 (1A), IC3.7 (2A), IC3.9 (3A), IC3.15 (4A), IC4.1 (1A), IC4.7 (2A), IC4.9 (3A), IC4.15 (4A)
/USB_D+: IC1.22 (PA12), J1.3 (D+)
/USB_D-: IC1.21 (PA11), J1.2 (D-)
/nRST: C5.1, IC1.4 (NRST), P1.3 (~RST)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, IC1.16 (VSS), IC1.31 (BOOT0), IC1.32 (VSS), IC2.1 (GND), IC3.8 (GND), IC3.12 (~G), IC4.8 (GND), IC4.12 (~G), J1.5 (GND), P1.5 (GND), P5.1
unnamed: IC3.2 (1Y), P6.1
unnamed: IC3.3 (1Z), P6.2
unnamed: IC3.5 (2Z), P7.2
unnamed: IC3.6 (2Y), P7.1
unnamed: IC3.10 (3Y), P8.1
unnamed: IC3.11 (3Z), P8.2
unnamed: IC3.13 (4Z), P9.2
unnamed: IC3.14 (4Y), P9.1
unnamed: IC4.2 (1Y), P10.1
unnamed: IC4.3 (1Z), P10.2
unnamed: IC4.5 (2Z), P11.2
unnamed: IC4.6 (2Y), P11.1
unnamed: IC4.10 (3Y), P12.1
unnamed: IC4.11 (3Z), P12.2
unnamed: IC4.13 (4Z), P13.2
unnamed: IC4.14 (4Y), P13.1

Notes on the sheet:
VDD1
VDD2
VDDA
Mounting Holes

Board: 2 copper layers, 50.0 x 50.0 mm, 29 parts (0 on the bottom side), 28 nets.

## KiCad design pcb2/pole/pole.kicad_pcb

Parts:
C1, C3, C5, C6: 100n; 0603
C2: 4u7; 0603
C4: 10n; 0603
C7: 10u; 0603
C8: 1u; 0603
IC1: LMx93; SOIC-8; Farnell 2342314
IC2: STM32F0xxKxUx; QFN-32-EP-ST; Farnell 2393639
P1: POWER_IN; minipow_edge
P2: BUS_IN; S02B-PASK-2
P3: BUS_OUT; S02B-PASK-2
P4: SWD_TC; TC2030-NL
P5: LEDs; Pin_Header_Straight_1x04
Q1, Q2, Q3, Q4: MTM232270LBF; SOT-323
R1, R2: 10k; 0603
R3: 1M; 0603
SP1: SPEAKER; piezo
TP1: RST; TESTPAD
U1: LD1117S33TR; TO-252-3

Connections:
+3V3: C1.2, C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, IC1.8 (VCC), IC2.1 (VDD), IC2.5 (VDDA), IC2.17 (VDD), P4.1 (VDD), R1.1, U1.2 (VO)
+12V: C6.1, P1.2, P5.1, SP1.1, U1.3 (VI)
/BUS: IC1.1 (1OUT), IC2.9 (PA3), R1.2, R3.1
/BUS_A: IC1.2 (1IN-), P2.1, P3.1
/BUS_B: P2.2, P3.2, R2.2
/DRIVE_B: P5.4, Q3.3 (D)
/DRIVE_G: P5.3, Q2.3 (D)
/DRIVE_R: P5.2, Q1.3 (D)
/LED_B: IC2.20 (PA10), Q3.1 (G)
/LED_G: IC2.19 (PA9), Q2.1 (G)
/LED_R: IC2.18 (PA8), Q1.1 (G)
/PIEZO: IC2.10 (PA4), Q4.1 (G)
/SWDCLK: IC2.24 (PA14), P4.4 (SWDCLK)
/SWDIO: IC2.23 (PA13), P4.2 (SWDIO)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, IC1.4 (GND), IC1.5 (2IN+), IC1.6 (2IN-), IC2.31 (BOOT0), IC2.EP (VSS), P1.1, P4.5 (GND), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), U1.1 (GND)
unnamed: IC1.3 (1IN+), R2.1, R3.2
unnamed: IC2.4 (NRST), TP1.1
unnamed: Q4.3 (D), SP1.2

Notes on the sheet:
Approx 50mV hysteresis

Board: 2 copper layers, 15.0 x 39.0 mm, 25 parts (2 on the bottom side), 18 nets.

## KiCad design pcb/thegrid.kicad_pcb

Board: 2 copper layers, 49.8 x 99.8 mm, 54 parts (0 on the bottom side), 35 nets.

Parts:
C1: .33u; C1
C2: .1u; C1
C3: 100n; C1
D1, D2, D3, D4, D5, D6, D7: LED; LED-5MM
MH: MountingHole_3mm_RevA_Date21Jun2010; MountingHole_3mm
MH#2, MH#3, MH#4: MountingHole_3mm_RevA_Date21Jun2010; MountingHole_3mm
P1: POWER; SIL-2
P2: SHIFT_IN; SIL-4
P3: SHIFT_OUT; SIL-4
P4, P5, P6, P7, P8, P9, P10: CONN_2; SIL-2
Q1, Q2, Q3, Q4, Q5, Q6, Q7: FQP7P06; TO220_VERT
R1, R3, R5, R7, R9, R11, R13: 10k; R3
R2, R4, R6, R8, R10, R12, R14: 100; R3
R15, R16, R17, R18, R19, R20, R21: 680; R3
U1: UA7805CKCS; TO220_VERT
U2: TPIC6C595; DIP-16__300

Connections:
+5V: C2.1, C3.1, U1.1, U2.1, U2.7
+12V: C1.1, P1.2, Q1.1, Q2.1, Q3.1, Q4.1, Q5.1, Q6.1, Q7.1, R1.2, R3.2, R5.2, R7.2, R9.2, R11.2, R13.2, U1.2
GND: C1.2, C2.2, C3.2, D1.2, D2.2, D3.2, D4.2, D5.2, D6.2, D7.2, P1.1, P2.1, P3.1, P4.2, P5.2, P6.2, P7.2, P8.2, P9.2, P10.2, U1.3, U2.8, U2.16
unnamed: D1.1, R15.1
unnamed: D2.1, R16.1
unnamed: D3.1, R17.1
unnamed: D4.1, R18.1
unnamed: D5.1, R19.1
unnamed: D6.1, R20.1
unnamed: D7.1, R21.1
unnamed: P2.2, P3.2, U2.10
unnamed: P2.3, P3.3, U2.15
unnamed: P2.4, U2.2
unnamed: P3.4, U2.9
unnamed: P4.1, Q1.3, R15.2
unnamed: P5.1, Q2.3, R16.2
unnamed: P6.1, Q3.3, R17.2
unnamed: P7.1, Q4.3, R18.2
unnamed: P8.1, Q5.3, R19.2
unnamed: P9.1, Q6.3, R20.2
unnamed: P10.1, Q7.3, R21.2
unnamed: Q1.2, R1.1, R2.1
unnamed: Q2.2, R3.1, R4.1
unnamed: Q3.2, R5.1, R6.1
unnamed: Q4.2, R7.1, R8.1
unnamed: Q5.2, R13.1, R14.1
unnamed: Q6.2, R9.1, R10.1
unnamed: Q7.2, R11.1, R12.1
unnamed: R2.2, U2.3
unnamed: R4.2, U2.4
unnamed: R6.2, U2.5
unnamed: R8.2, U2.6
unnamed: R10.2, U2.12
unnamed: R12.2, U2.13
unnamed: R14.2, U2.11

## Commit log (part)

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2016-03-27 Added board-outline
2016-03-27 Added shield schematic
2016-03-27 Added comparator receiver hysteresis
2016-03-27 Added SHIFT connections, sated ERC
2016-03-28 Proof of concept route of shield
2016-03-28 Cleared up routing, added+stitched top gnd plane
2016-03-28 Moved JST-PAs inward, silk
2016-03-28 Shrunk shield board outline to fit 5x5
2016-03-28 re-layout and reroute of pole pcb
2016-03-28 Added pole silk
2016-03-28 Added panellised pole pcb
2016-03-28 Changed vias from 0.6/0.4 to 0.6/0.3
2016-03-28 Removed erroneous edge cut
2016-03-29 set mask clearance to 0 and regen gerbers
2016-03-29 gerbers to manufacturing
2016-03-29 Added part numbers and BOMs
2016-04-07 thegrid2 data cable cutting list
2016-04-13 rename gm1 to gml for dirty
2016-04-13 chibios project
2016-04-13 add simple fading example using PWM
2016-04-13 add first go at leonardo code v2
2016-04-16 BOM stuff
2016-04-18 Updated control sw requirements.txt
2016-04-18 tkinter colour patterns and sample colour pattern
2016-04-18 Make tkinter default sink, delete console sink
2016-04-18 Removed console sink from sink list
2016-04-18 list patterns command, list sinks command
2016-04-18 Colour support for legacy patterns
2016-04-18 List commands in API
2016-04-19 Converted pattern_one.py to generators as demo
2016-04-19 updated snake to colour!
2016-04-19 Don't spawn food inthe snake!
2016-04-19 Stripey snake
2016-04-19 basic midi file pattern
2016-04-19 Use all poles for channels, midi thru
2016-04-20 Improved MIDI passthrough
2016-04-20 First prototype diffusion pattern
2016-04-21 Chaged colourgrid to uint8
2016-04-21 add reloading patterns live
2016-04-22 fix pattern reloading
2016-04-25 fix reloading patterns
2016-04-25 remove unnecessary clear()
2016-04-27 various audio work
2016-04-29 David's mac AMP programmer
2016-04-30 Hyper-realistic fire flicker effect
2016-05-07 have sine.py take cmdline arg for wav file
2016-06-14 Handle Midi NoteOffEvents
2016-06-14 Colour wheel hsv demo pattern
2016-06-14 radar pattern with static targets list
2016-06-14 added previous 2 patterns to __init__
2016-06-14 Added radar pattern with moving targets
2016-06-15 VU alsa pattern
2016-07-22 Only import patterns if deps exist
2016-07-22 Removed debug text from snake pattern
2016-07-23 Added flash verification and boop-program script
2016-07-23 New colourful static patterns, spin and zoom
2016-07-23 New colourwave pattern
2016-07-23 Added sublime fading effect to colourwave
2016-07-23 add testfw
2016-07-23 py3 magic
2016-07-23 don't beep on serial fail
2016-07-23 Moved beepety boop
2016-07-24 Game of life pattern
2016-07-24 first serious go at firmware
2016-07-24 update testbench to do all 49 channels different hues
2016-07-24 Repsin of new shield PCB, nominal first route.
2016-07-24 Re-route of shield, DRC issues though.
2016-07-24 Added "spotlights" pattern
2016-07-24 Changed pattern imports to one per line
2016-07-24 work on sound stuff
2016-07-24 shield PCB ERC
2016-07-24 Ground planes and stitching
2016-07-24 Shield PCB r2 nominally finished.
2016-07-29 add webgl+websockets based simulator
2016-07-29 Added parts, BOM and stickerBOM
2016-07-30 GOL: Added colour and random start options
2016-07-30 Added GOL boredom detector
2016-07-30 Fixed bug in colour-change-on-death in GOL
2016-07-30 Spectrogram pattern
2016-07-31 driver fw
2016-07-31 add set_ids.py script
2016-07-31 Started Captain Kirk pattern
2016-07-31 Updated __init__ for patterns
2016-07-31 Updated barbeat so we actually start on beat 1not2
2016-07-31 BPS tends to refer to BPS, not beat period...
2016-07-31 Captain Kirk: first half.
2016-07-31 More work on kirk
2016-07-31 Achievement unlocked: Shatner of the mount
2016-07-31 Bugfixes to poor Shatner
2016-07-31 musicpattern hint: start beat seek
2016-07-31 Added pyglet to requirements.txt for music patterns
2016-08-01 add (dis)connected indicator to sim3d
2016-08-01 first shot at control2
2016-08-01 first go at api thing
2016-08-01 copy all the patterns into control2
2016-08-01 add requirements.txt
2016-08-01 don't use -e in requirements
2016-08-01 Made reqiremetns.txt exhaustive
2016-08-01 GOL wants to be 30fps
2016-08-01 kirk: higher fps, fixed super() bug
2016-08-01 Increased contrast on sim3d
2016-08-01 add overflow hidden to sim3d
2016-08-01 Fixed colourwheel
2016-08-01 adam srsly
2016-08-01 Fixed/improved some patterns, changed naming scheme
2016-08-01 New GRIDI segmentation strategy
2016-08-01 Added file selecta for gridi
2016-08-01 Working on colour ripple pattern
2016-08-01 Now overriding __init__ method, need to take two positional args and pass to super. Moved grid generator out of update method. Working, but not quite doing what I want
2016-08-01 Fixed some bugs, still not doing what I want bc we don't remember old colours in the main generator. Will fix
2016-08-01 Various improvements to gridi
2016-08-01 Removed Shatner's baps.
2016-08-01 Removed deprecated delete() of musicfile/staticsource
2016-08-01 New DepMod MIDIs, thanks Kliment
2016-08-02 sound stuff
2016-08-02 fix annoying sound issue
2016-08-02 Updating colour ripple, though WebGL not working on this computer so haven't tested. Now have LIFO queue of colours generated from linear_colour_gradient, and don't next() unneccessarily@
2016-08-02 Replaced ranges with lists to be clearer
2016-08-02 Changed to FIFO queue, had not thought through
2016-08-02 Fixed silly for range(1, n) to for range(n)
2016-08-02 Didn't realise q.put would hang if queue full; thought it would pop. Need to fix
2016-08-02 Fixed bugs! 1. If iterating over multiple counters, need to zip the iterables, obviously! 2. Need to copy the deque or else it will become depleted. Now just need to modify the colour gradient so it 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
2016-08-02 Removed some debug statements
2016-08-02 Now flows through patterns much more smoothly and nicely. Problems: finishes once it gets to white; doesn't go through whole rainbow
2016-08-02 Playing about with different colour gradient paths
2016-08-02 Updated docstrings
2016-08-02 back on computer without webgl. Think I've fixed the gradient so it looks more like a rainbow -- I was only interpolating in one channel. In retrospect, it seems obvious that we should interpolate in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
2016-08-02 Removed debug print statement
2016-08-02 adjusted the referesh rate and the number of interpolation steps. Lookin crackin!
2016-08-02 Rename colourripple to match new naming convention
2016-08-02 Started work on colour runner pattern
2016-08-02 Added colour runner pattern to __init__.py. Updated docstring of generate_grid method, as it contained old info copied from colour ripple pattern. Now method runner_location randomly picks a start va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
2016-08-02 Location now moves from (0, 0) to (0, 6), then stops. Next step is to move through whole grid
2016-08-02 Now the runner infinitely snakes through the grid. Itertools is awesome and so am i <3. Need to reinitalise grid each loop through generate_grid, otherwise runner will be duplicated. Next step is ini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
2016-08-02 Now initialise to blue and it looks great! Looking at aerial view can see the path through grid is not quite as I thought. next step: debugging
2016-08-02 Now snakes through grid properly. The iterators for x and y were out of sync
2016-08-02 Fixed minor 'bug' in colour ripple, where I was appending left and also popping left. Want to have opposites! Now plain pop and i think it looks better! Not a huge difference though
2016-08-02 only fixed one of the poplefts in colour ripple
2016-08-02 trying to track down a stupid bug but i am too sleepy
2016-08-03 [cleanup 1] remove all submodules, it's just easier
2016-08-03 [cleanup 2] remove all old directories
2016-08-03 [cleanup 3] remove testfw
2016-08-03 [cleanup 4] move firmware into firmware/ and clean up chibios patching
2016-08-03 [cleanup 5] Move PCBs into hardware/
2016-08-03 [cleanup 6] move control2/ into software/
2016-08-03 [cleanup 7] move laser, docs, scripts into misc
2016-08-03 set chibios submodule to 16.1.x stable head
2016-08-03 add quicktest.py script
2016-08-03 quick new blog post
2016-08-03 Update documentation
2016-08-03 add StopIteration feature to patterns and example 'Stopping' pattern
2016-08-03 fix simulator sounds
2016-08-03 generate StickerBOM for driver board
2016-08-03 On VM where WebGL won't work, so can't test properly: but! From debug statements, it looks like I have fixed at least some of the problem. I think I was just getting confused about which end I was ad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
2016-08-03 Added pyglet to requirements for music patterns
2016-08-03 Fixed non-integer barbeat in musicpatterns
2016-08-03 Fixed docstring in captain kirk
2016-08-03 Added template AYB pattern with beat-mapping
2016-08-03 More ayb
2016-08-03 Looks like the bugs have indeed been solved, though only tested on a computer that could run webgl verrryy slowly. Hooray! Currently have the red runner snaking through the blue grid ad infinitum, wi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
2016-08-03 merge
2016-08-03 Updated docstrings, and added kwarg to generate_grid for the length of the wake
2016-08-03 check node id is in bounds at boot
2016-08-03 Adam you have betrayed me with this refactor. I am emerging a husk after this awful merge
2016-08-03 Accidentally included my venv bc I foolishly don't have a .gitignore
2016-08-04 have separate idle thread so main can sleep
2016-08-04 fix up driver fw issues
2016-08-04 add quickderp i guess
2016-08-04 go red on checksum error
2016-08-04 better soundbench
2016-08-04 updated beepety boop for linux
2016-08-04 updated web pages/api
2016-08-04 Fixing up for pull request
2016-08-05 fix driver board power control
2016-08-05 change driver baud to 1M
2016-08-05 move checksums to each packet
2016-08-05 Fixed now playing when no pattern loaded
2016-08-05 update to new serial format
2016-08-05 Added piezo sounds to all patterns
2016-08-05 Fix my wrong merge-commit fix
2016-08-05 update serial for new serial format
2016-08-05 update firmware for high baud, low pwm, new frame
2016-08-05 Don't use full volume on beepers
2016-08-05 Add power off when off
2016-08-05 Fix the weird serial.write
2016-08-05 Fix weirdness in off-ness
2016-08-05 Temporary addressing
2016-08-05 Added colour runner rainbow pattern!
2016-08-05 Created parent Runner class and moved rainbow runner and colour runner into one file
2016-08-05 Made the snake in rainbow runner a bit shorter so that it doesn't take up two rows
2016-08-05 Added silent import to spotlights
2016-08-05 Fixed return type in snake patterns
2016-08-06 Add watchdog timer
2016-08-06 Added colour patterns playlist
2016-08-06 Updated midi submodule path
2016-08-06 drop pwm freq to reduce error rate
2016-08-06 Add missing watchdog.{c,h}
2016-08-06 Improved fire pattern by copying OHM torches
2016-08-06 Updated fire pattern to return correct shape
2016-08-06 Started making annihilation pattern
2016-08-06 Moved annihilation pattern into runner module
2016-08-06 Abstracted some stuff into a function run
2016-08-06 Now the two rainbows meet in the middle, forming an increasingly bright white centre. Next step is to asplode!
2016-08-06 Now it asplodes! Now to tidy up
2016-08-06 tidied up a bit, but think the explosion could look better
2016-08-06 My tidies actually messed some stuff up! In-line time
2016-08-06 Now has a nice fade after explosion
2016-08-06 Added some hopefully elucidating comments. Finding it a bit trickier to split up generators than subroutines, so the generate_grid method is longer than I would like. Might be time for a refactor to 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
2016-08-06 fixed typo in comment where grid was spelt grade
2016-08-06 Added some nested functions. Would be interesting to chat with someone about whether this is a better approach! I think it makes it a bit clearer what's going on while avoiding comments, but maybe it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
2016-08-06 Removed pause before asploding
2016-08-06 Added Annihiliation pattern
2016-08-06 Removed bohemian, it won't stop crashing
2016-08-06 Added sound to annihilation pattern, now sounds like an incoming with descending pitch, and then clicks for the explosion
2016-08-06 Added new midi patterns
2016-08-06 WIP Pong 2P
2016-08-06 more midis
2016-08-07 More pong (+ui)
2016-08-07 AYB pattern finished
2016-08-07 invert rows and cols in power-cut-hack
2016-08-10 add takecontrol sign
